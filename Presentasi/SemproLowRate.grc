options:
  parameters:
    author: Bima
    generate_options: qt_gui
    id: generateFmcw2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 3.1e9
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**5
  states: {}
- name: maxOutputBuffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: meas_duration
  id: variable
  parameters:
    value: (samp_cw+samp_up+samp_down)/float(samp_rate)
  states: {}
- name: minOutputBuffer
  id: variable
  parameters:
    value: int((samp_up+samp_down+samp_cw)*2)
  states: {}
- name: protect_samp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/sweep_freq
  states: {}
- name: samp_cw
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: samp_down
  id: variable
  parameters:
    value: samp_up
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_up
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: sweep_freq
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: v_res
  id: variable
  parameters:
    value: samp_rate/samp_cw*3e8/2/center_freq
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    label: range
    start: '0'
    step: '1'
    stop: '1000'
    value: '200'
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    minoutbuf: minOutputBuffer
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: minOutputBuffer
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: minOutputBuffer
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    minoutbuf: minOutputBuffer
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '1'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '-sweep_freq/2'
    freq_sweep: sweep_freq
    len_key: packet_len
    minoutbuf: minOutputBuffer
    samp_cw: samp_cw
    samp_down: samp_down
    samp_rate: samp_rate
    samp_up: samp_up
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: packet_len
    minoutbuf: minOutputBuffer
    position_rx: '0'
    range: value_range
    rcs: 1e16
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: velocity
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_sink_x_1, '0']
- [blocks_throttle2_0, '0', radar_static_target_simulator_cc_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_throttle2_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', radar_static_target_simulator_cc_0, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
